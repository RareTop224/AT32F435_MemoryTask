# Keil uVision project project.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: -AT32F435ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.4
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Users\butyl\AppData\Local\Arm\Packs\ArteryTek\AT32F435_437_DFP\2.2.4\Device\Firmware\Peripherals\inc;C:\Users\butyl\AppData\Local\Arm\Packs\ArteryTek\AT32F435_437_DFP\2.2.4\Device\Utilities;C:\Users\butyl\AppData\Local\Arm\Packs\ArteryTek\AT32F435_437_DFP\2.2.4\Device\Include
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group src
    ./: main.c program2.c program3.c
software components: CMSIS:CORE 6.1.1, Device:Startup 2.0.0, Device:at32f435_437_conf 2.0.0, Device:at32f435_437_firmware_library:crm 2.0.0, Device:at32f435_437_firmware_library:exint 2.0.0, Device:at32f435_437_firmware_library:gpio 2.0.0, Device:at32f435_437_firmware_library:misc 2.0.0, Device:at32f435_437_firmware_library:scfg 2.0.0, Device:at32f435_437_firmware_library:usart 2.0.0
